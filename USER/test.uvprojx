# Keil uVision project test.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PM25_CO2_HUM_RESSURE_REV59 +hex
  c flags: Optim=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLib\inc;..\HARDWARE\LED;..\HARDWARE\LCD;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM;..\HARDWARE\KEY;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\TOUCH;..\HARDWARE\FLASH;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\SDCARD;..\FATFS\src;..\FATFS\exfuns;..\VMALLOC;..\HARDWARE\TIMER;..\HARDWARE\ENC28J60;..\uIP-1.0\uip;..\uIP-1.0\apps\dhcpc;..\uIP-1.0\apps\resolv;..\uIP-1.0\apps\webserver;..\uIP-APP;..\HARDWARE\RTC;..\USB\CONFIG\inc;..\USB\LIB\inc;..\USB\APP;..\MODBUS;..\TCPIP;..\KEY;..\bac_lib\h_header;..\FILTER;..\RANGE;..\baclib\include;..\baclib;..\INPUT_LIB;..\STORE_DATA;..\INFO;..\MENU;..\baclib\object;..\baclib\include;..\HARDWARE\HUMIDITY;..\TEMPERATURE;..\HARDWARE\ESP8266
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c FreeRTOSConfig.h
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_bkp.c stm32f10x_pwr.c
  group CMSIS
    ../CORE/: cortexm3_macro_rvds.s core_cm3.c startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TIMER/: timerx.c
    ../HARDWARE/ENC28J60/: enc28j60.c
    ../HARDWARE/LCD/: LCD.c spec_font.c ER-TFT024-3_4-Wire_SPI.c
    ../HARDWARE/SDCARD/: MMC_SD.C
    ../HARDWARE/RTC/: rtc.c
    ../KEY/: key.c
    ../HARDWARE/HUMIDITY/: humidity.c i2c_hal.c sht3x.c
    ./: analog_inputs.c
  group FREERTOS
    ../FreeRTOS/: tasks.c list.c queue.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
  group UIP-1.0
    ../uIP-1.0/uip/: psock.c timer.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group UIP-APP
    ../uIP-APP/: clock-arch.c tapdev.c tcp_demo.c tcp_modbus.c udp_scan.c
    ../uIP-1.0/apps/dhcpc/: dhcpc.c
    ../uIP-1.0/apps/resolv/: resolv.c
  group MODBUS
    ../MODBUS/: modbus.c crc.c
  group BACLIB
    ../baclib/: bacnet_function.c bip.c bacnet_ARM_rev15_co2.lib
  group INPUT_LIB
    ../INPUT_LIB/: io_control.c outputs.c inputs.c
  group STORE
    ../STORE_DATA/: store.c
  group INFO
    ../INFO/: info.c
  group CO2
    ../co2/: co2.c sub_net.c subnet_scan.c scan.c
  group OUTPUT
    ../OUTPUT/: analog_output.c
  group TEMPERATURE
    ../TEMPERATURE/: temperature.c Hum_Para.c
  group MENU
    ../MENU/: Menu.c menuAbout.c menuCo2_Conf.c menuCo2_Opt.c menuHum_Conf.c menuIdle.c menuMain.c menuMisc.c menuTemp_Conf.c
  group Pressure
    ../PRESSURE/: pressure.c DLVR-L01D.c
  group PID
    ../PID/: pid.c
  group PM25
    ../PM25/: pm25.c aqi.c
  group wifi
    ./: wifi.c bsp_esp8266.c
